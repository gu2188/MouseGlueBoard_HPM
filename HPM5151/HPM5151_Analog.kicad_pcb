# Repository gu2188/MouseGlueBoard_HPM

File README.md:

The first version of HPM5301 has been updated.

The first version of HPM5E31 has been updated.

## KiCad design HPM5151/HPM5151_Analog.kicad_pcb

Board: 6 copper layers, 78 parts (0 on the bottom side), 28 nets, no tracks yet.

Parts:
C1, C5, C6, C27, C28, C29, C30, C37, C39: 10uF; C_0402_1005Metric
C2, C3, C4, C7, C8, C11, C18, C31, C32, C33, C35, C36, C38: 100nF; C_0402_1005Metric
C9, C10, C23, C24: 22uF/25V; C_0603_1608Metric
C12, C13: 10uF/25V; C_0603_1608Metric
C14, C15, C16, C17, C25, C26: 100nf; C_01005_0402Metric
C19, C20: 100nf; C_0603_1608Metric
C21, C22: 47uF/25V; C_0603_1608Metric
C34: 4.7uF; C_0402_1005Metric
C40, C41: 12pF; C_0402_1005Metric
D1: PESD5V0L1BA; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_DIN965_Pad
L1: 4.7uH; L_1008_2520Metric
L2: 2.2uH; L_1008_2520Metric
R1, R2: 1K; R_0603_1608Metric
R3, R13, R14, R15, R16, R17: 10K; R_0402_1005Metric
R4: 0R; R_0402_1005Metric
R5, R6: DNP; R_0402_1005Metric
R7: 31.3K 1%; R_0402_1005Metric
R8, R10: 10K 1%; R_0402_1005Metric
R9: 5.1K 1%; R_0402_1005Metric
R11, R12: 5.1K; R_0402_1005Metric
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: HPM5151IN81; QFN-68-1EP_8x8mm_P0.4mm_EP5.5x5.5mm-300N
U2: REF3433IDBVR; REF3433IDBVR_C882722
U3: OPA320AIDBVR; SOT-23-5
U4: TS-1088R-02026; TS-1088R-02026_C455280
U5, U6: TPS62933; SOT-583-8
U7: PRTR5V0U2X_C2827688; PRTR5V0U2X_C2827688_C2827688
U8: X6521WV-2X30H-C30D60; X6521WV-2X30H-C30D60_C2883964
U9: 1.25-5P WT; 1_25-5P_WT_C668616
U10: DSHP02TSGER; DSHP02TSGER_C3293142
Y1: 24Mhz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
1V2: C22.2, C24.2, C26.2, L2.2, R9.2, U1.3 (VDD_SOC), U1.54 (VDD_SOC), U1.65 (VDD_SOC)
3V3: C2.1, C21.2, C23.2, C25.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C36.1, C37.1, C38.1, C39.1, L1.2, R3.1, R7.2, R13.1, R14.1, R15.1, R16.1, R17.1, U1.8 (VIO_B00), U1.14 (VPMC), U1.32 (VIO_B03), U1.48 (VIO_B02), U1.55 (VPLLVUSB), U1.60 (VIO_B01)
3V3A: C1.1, C4.1, U1.20 (VANA)
5V: C6.1, C7.1, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, D1.2 (A2), U2.3 (ENABLE), U2.4 (IN), U5.3 (VIN), U6.3 (VIN), U7.4
/CONNECTOR/TDI: R13.2, U9.3
/CONNECTOR/TDO: R15.2, U9.2
/CONNECTOR/TMS: R14.2, U9.5
/CONNECTOR/XTALI: C40.2, Y1.3
/CONNECTOR/XTALO: C41.2, Y1.1
/POWER/RESETN: C11.1, R3.2, U1.18 (RESETN), U4.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.2, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.2, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.1, C41.1, D1.1 (A1), R2.2, R5.1, R6.1, R8.1, R10.1, R11.2, R12.2, U1.21 (VREFL), U1.22 (VSSA), U1.69 (PAD), U2.1 (GND_F), U2.2 (GND_S), U3.2 (V-), U4.2, U5.4 (GND), U6.4 (GND), U7.1, U9.1, U9.6, U9.7, Y1.2, Y1.4
unnamed: R16.2, U10.4
unnamed: R17.2, U10.3
unnamed: C34.1, C35.1, U1.13 (VPMCCAP)
unnamed: R1.2, R2.1, U3.3 (+)
unnamed: R4.1, U3.1, U3.4 (-)
unnamed: C19.1, U5.6 (BST)
unnamed: R7.1, R8.2, U5.8 (FB)
unnamed: R5.2, U5.1 (RT)
unnamed: C16.2, U5.7 (SS)
unnamed: C19.2, L1.1, U5.5 (SW)
unnamed: C20.1, U6.6 (BST)
unnamed: R9.1, R10.2, U6.8 (FB)
unnamed: R6.2, U6.1 (RT)
unnamed: C17.2, U6.7 (SS)
unnamed: C20.2, L2.1, U6.5 (SW)
REF1V65: C18.1, R4.2, TP2.1 (1_1)
VREF3V3: C3.1, C5.1, C8.1, R1.1, TP1.1 (1_1), U1.19 (VREFH), U2.5 (OUT_S), U2.6 (OUT_F)

## KiCad design HPM5E31/HPM5E31.kicad_pcb

Parts:
C35, C37, C39, C41, C43, C45: 10uF; C_0402_1005Metric
C36, C38, C40, C42, C44, C46, C47, C48: 100nF; C_0402_1005Metric
D2, D3: LED; LED_0603_1608Metric
J2: 3220-10-0100-00; PinHeader_2x5_P1.27mm_Drill.7mm; MPN 3220-10-0100-00; Digi-Key_PN 1175-1627-ND
R7, R8: 1K; R_0402_1005Metric
R9, R10, R11, R12, R13: 10K; R_0402_1005Metric
SW3, SW4: SW-SMD_L3.9-W3.0-P4.45; Manufacturer Part TS-1088R-02026; LCSC Part Name 3.9*2.93*2mm 立贴 轻触开关
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm

Connections:
/3V3: C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, J2.1, R7.1, R8.1, R10.1, R11.1, SW3.1, SW4.1, U1.19 (VIO_B01), U1.55 (VIO_B01), U1.66 (VIO_B01), U1.72 (VIO_B01), U1.82 (VIO_B01), U1.99 (VIO_B01); also elsewhere on the board
/ESC0.P0_RXCK: U1.20 (PA21/GPTMR3.COMP2/UART5.DE/UART5.RTS/SP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); also elsewhere on the board
/ESC0.P0_RXD0: U1.27 (PA17/GPTMR3.CAPT0/UART4.RXD/ESC0.P0_RXD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); also elsewhere on the board
/ESC0.P0_RXD1: U1.26 (PA18/GPTMR3.COMP1/UART4.DE/UART4.RTS/ES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); also elsewhere on the board
/ESC0.P0_RXD2: U1.25 (PA19/GPTMR3.CAPT1/UART4.CTS/SPI3.CS3/ES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); also elsewhere on the board
/ESC0.P0_RXD3: U1.21 (PA20/UART5.CTS/SPI2.SCLK/ESC0.P0_RXD3/S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); also elsewhere on the board
/ESC0.P0_RXDV: U1.28 (PA16/GPTMR3.COMP0/UART4.TXD/ESC0.P0_RXD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); also elsewhere on the board
/ESC0.P0_RXER: U1.15 (PA23/GPTMR2.COMP0/UART5.TXD/SPI2.MOSI/E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); also elsewhere on the board
/ESC0.P0_TXCK: U1.24 (PA24/GPTMR2.COMP1/UART6.TXD/SPI3.CS2/ES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); also elsewhere on the board
/ESC0.P0_TXD0: U1.22 (PA25/GPTMR2.CAPT1/UART6.RXD/SPI3.CS1/ES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); also elsewhere on the board
/ESC0.P0_TXD1: U1.18 (PA26/GPTMR2.COMP2/UART6.DE/UART6.RTS/SP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); also elsewhere on the board
/ESC0.P0_TXD2: U1.17 (PA27/UART6.CTS/SPI3.CS0/ESC0.P0_TXD2/QE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); also elsewhere on the board
/ESC0.P0_TXD3: U1.16 (PA28/UART7.CTS/SPI3.MISO/ESC0.P0_TXD3/E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); also elsewhere on the board
/ESC0.P0_TXEN: U1.14 (PA29/GPTMR3.COMP3/UART7.DE/UART7.RTS/SP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); also elsewhere on the board
/JTAG_BOOT_ESC/BOOT0: C47.1, R12.1, SW3.2, U1.7 (PA02/GPTMR1.COMP1/UART0.DE/UART0.RTS/I2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)
/JTAG_BOOT_ESC/BOOT1: C48.1, R13.1, SW4.2, U1.6 (PA03/GPTMR1.CAPT1/UART0.CTS/I2C2.SDA/MC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)
/JTAG_BOOT_ESC/ESC0.P1_RXCK: U1.59 (PF13/I2C1.SCL/MCAN3.STBY/ESC0.P1_RXCK/P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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD0: U1.62 (PF09/I2C0.SDA/MCAN2.RXD/ESC0.P1_RXD0/PW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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD1: U1.53 (PF10/MCAN2.STBY/ESC0.P1_RXD1/PWM1.P2/TR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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD2: U1.65 (PF11/ESC0.P1_RXD2/PWM1.P3/TRGM.P11/ETH0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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD3: U1.60 (PF12/I2C1.SDA/ESC0.P1_RXD3/PWM1.P4/TRGM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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXDV: U1.64 (PF08/I2C0.SCL/MCAN2.TXD/ESC0.P1_RXDV/PW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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXER: U1.54 (PF14/MCAN3.RXD/ESC0.P1_RXER/PWM1.P6/TRG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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXCK: U1.57 (PF02/I2C2.SCL/MCAN0.STBY/ESC0.P1_TXCK/P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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD0: U1.63 (PF03/I2C2.SDA/MCAN1.STBY/ESC0.P1_TXD0/P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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD1: U1.51 (PF04/MCAN1.RXD/ESC0.P1_TXD1/PWM0.P4/TRG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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD2: U1.56 (PF05/MCAN1.TXD/ESC0.P1_TXD2/PWM0.P5/TRG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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD3: U1.58 (PF06/I2C3.SDA/ESC0.P1_TXD3/PWM0.P6/TRGM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); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXEN: U1.61 (PF07/I2C3.SCL/ESC0.P1_TXEN/PWM0.P7/TRGM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); also elsewhere on the board
/JTAG_BOOT_ESC/RX: J2.7, U1.9 (PA01/GPTMR1.CAPT0/UART0.RXD/MCAN0.RXD/P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)
/JTAG_BOOT_ESC/SYS_LED: D3.1 (K), U1.10 (PA22/GPTMR2.CAPT0/UART5.RXD/SPI2.MISO/E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)
/JTAG_BOOT_ESC/TCK: J2.4, R9.1, U1.1 (PA06/GPTMR0.CAPT0/UART1.RXD/I2C3.SDA/SP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)
/JTAG_BOOT_ESC/TDI: J2.6, R11.2, U1.2 (PA05/GPTMR1.COMP2/UART1.DE/UART1.RTS/SP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)
/JTAG_BOOT_ESC/TDO: J2.8, U1.3 (PA04/UART1.CTS/SPI1.SCLK/MCAN1.RXD/PWM0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)
/JTAG_BOOT_ESC/TMS: J2.2, R10.2, U1.100 (PA07/GPTMR0.COMP0/UART1.TXD/I2C3.SCL/SP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)
/JTAG_BOOT_ESC/TRST: J2.10, U1.8 (PA08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/MC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)
/JTAG_BOOT_ESC/TX: J2.9, U1.11 (PA00/GPTMR1.COMP0/UART0.TXD/MCAN0.TXD/P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)
/MDC: U1.12 (PA31/GPTMR2.COMP3/UART7.TXD/SPI3.DAT3/E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); also elsewhere on the board
/MDIO: U1.13 (PA30/UART7.RXD/SPI3.DAT2/ESC0.MDIO/ETH0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); also elsewhere on the board
/REFCK: U1.5 (PA09/GPTMR0.CAPT1/UART2.RXD/I2C0.SDA/MC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); also elsewhere on the board
GND: C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, D2.1 (K), J2.3, J2.5, R9.2, R12.2, R13.2; also elsewhere on the board
unnamed: D2.2 (A), R7.2
unnamed: D3.2 (A), R8.2

Notes on the sheet:
电源和 用户LED指示灯
ESC,JTAG,BOOT和电源部分
JTAG调试接口
电源输入和滤波电容
BOOT按键

Parts:
C49, C50, C51, C52: 10uF; C_0402_1005Metric
C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63: 100nF; C_0402_1005Metric
J3, J4: RJ45_Hanrun_HR911105A_Horizontal
R14: 10K; R_0402_1005Metric
R15, R16, R23, R24, R25, R26: 4.7K; R_0402_1005Metric
R17, R18, R19, R20: 33; R_0402_1005Metric
R21, R22: 2.49K 1%; R_0402_1005Metric
R27, R28, R29, R30: 330; R_0402_1005Metric
U3, U4: JL1111-N032I; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections:
/3V3: C49.2, C50.2, C54.2, C55.2, C58.2, C59.2, J3.9, J4.12, R14.2, R15.1, R16.1, R24.1, R25.1, U3.7 (AVDD33), U3.14 (DVDDIO), U4.7 (AVDD33), U4.14 (DVDDIO); also elsewhere on the board
/ESC0.P0_LINK: J3.12, R23.1, U3.25 (LED1); also elsewhere on the board
/ESC0.P0_RXCK: R18.1; also elsewhere on the board
/ESC0.P0_RXD0: U3.9 (RXD0); also elsewhere on the board
/ESC0.P0_RXD1: U3.10 (RXD1); also elsewhere on the board
/ESC0.P0_RXD2: U3.11 (RXD2/INT_N); also elsewhere on the board
/ESC0.P0_RXD3: U3.12 (RXD3); also elsewhere on the board
/ESC0.P0_RXDV: U3.8 (RX_DV); also elsewhere on the board
/ESC0.P0_RXER: U3.28 (RX_ER); also elsewhere on the board
/ESC0.P0_TXCK: R17.1; also elsewhere on the board
/ESC0.P0_TXD0: U3.16 (TXD0); also elsewhere on the board
/ESC0.P0_TXD1: U3.17 (TXD1); also elsewhere on the board
/ESC0.P0_TXD2: U3.18 (TXD2); also elsewhere on the board
/ESC0.P0_TXD3: U3.19 (TXD3); also elsewhere on the board
/ESC0.P0_TXEN: U3.20 (TX_EN); also elsewhere on the board
/ESC0.P1_LINK: J4.9, R26.1, U4.25 (LED1); also elsewhere on the board
/ESC0_RESET: C53.2, R14.1, U3.21 (RESET_N), U4.21 (RESET_N); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXCK: R20.1; also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD0: U4.9 (RXD0); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD1: U4.10 (RXD1); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD2: U4.11 (RXD2/INT_N); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXD3: U4.12 (RXD3); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXDV: U4.8 (RX_DV); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_RXER: U4.28 (RX_ER); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXCK: R19.1; also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD0: U4.16 (TXD0); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD1: U4.17 (TXD1); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD2: U4.18 (TXD2); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXD3: U4.19 (TXD3); also elsewhere on the board
/JTAG_BOOT_ESC/ESC0.P1_TXEN: U4.20 (TX_EN); also elsewhere on the board
/MDC: R16.2, U3.22 (MDC), U4.22 (MDC); also elsewhere on the board
/MDIO: R15.2, U3.23 (MDIO), U4.23 (MDIO); also elsewhere on the board
/NETWORK/P0_LED0: R24.2, R28.2, U3.24 (LED0)
/NETWORK/P0_RD_N: J3.6 (RD-), U3.6 (RD_N)
/NETWORK/P0_RD_P: J3.3 (RD+), U3.5 (RD_P)
/NETWORK/P0_TD_N: J3.2 (TD-), U3.4 (TD_N)
/NETWORK/P0_TD_P: J3.1 (TD+), U3.3 (TD_P)
/NETWORK/P01V2: C51.2, C56.2, U3.29 (DVDD1V2)
/NETWORK/P1_LED0: R25.2, R29.2, U4.24 (LED0)
/NETWORK/P1_RD_N: J4.6 (RD-), U4.6 (RD_N)
/NETWORK/P1_RD_P: J4.3 (RD+), U4.5 (RD_P)
/NETWORK/P1_TD_N: J4.2 (TD-), U4.4 (TD_N)
/NETWORK/P1_TD_P: J4.1 (TD+), U4.3 (TD_P)
/NETWORK/P11V2: C52.2, C57.2, U4.29 (DVDD1V2)
/REFCK: U3.31 (XI), U4.31 (XI); also elsewhere on the board
GND: C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.2, C61.2, C62.2, C63.2, J3.8, J3.SH, J4.8, J4.SH, R21.2, R22.2, R23.2, R26.2, R27.2, R30.2, U3.33 (GND), U4.33 (GND); also elsewhere on the board
unnamed: J3.10, R28.1
unnamed: J3.11, R27.1
unnamed: C61.1, J3.5 (RCT)
unnamed: C60.1, J3.4 (TCT)
unnamed: J4.10, R30.1
unnamed: J4.11, R29.1
unnamed: C63.1, J4.5 (RCT)
unnamed: C62.1, J4.4 (TCT)
unnamed: R21.1, U3.1 (RBIAS)
unnamed: R18.2, U3.13 (RXC)
unnamed: R17.2, U3.15 (TXC)
unnamed: R22.1, U4.1 (RBIAS)
unnamed: R20.2, U4.13 (RXC)
unnamed: R19.2, U4.15 (TXC)

Notes on the sheet:
电源输入,外围电路 和滤波电容
ESC PHY -P1
ESC PHY -P0

Parts:
C33: 100nF; C_0402_1005Metric
C34: 10uF; C_0402_1005Metric
H1: HDR-TH_40P-P2.54-V-M-R2-C20-S2.54; Manufacturer Part B-2100S40P-B110; LCSC Part Name 2x20P 间距:2.54mm 直插
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm

Connections:
/3V3: C33.1, C34.1, H1.35, H1.36, H1.37, H1.38, U1.45 (VIO_B02); also elsewhere on the board
/5V: H1.39, H1.40; also elsewhere on the board
/ESC0.P0_LINK: U1.96 (PB27/ESC0.CTR7/XPI0.CA_D0/QEI1.F/SDM0.D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); also elsewhere on the board
/ESC0.P1_LINK: U1.95 (PB28/ESC0.CTR8/XPI0.CA_D1/QEI1.H0/SDM0.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); also elsewhere on the board
/ESC0_RESET: U1.97 (PB26/ESC0.CTR6/XPI0.CA_D2/QEI1.H1/SDM0.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); also elsewhere on the board
/IO/PB29: H1.1, U1.94 (PB29/XPI0.CA_SCLK/QEI1.Z/SDM0.DAT1/ETH0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)
/IO/PB30: H1.2, U1.93 (PB30/ESC0.CTR7/XPI0.CA_CS0/QEI1.A/SDM0.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)
/IO/PB31: H1.3, U1.92 (PB31/ESC0.CTR8/XPI0.CA_D3/QEI1.B/SDM0.D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)
/IO/PC08: H1.4, U1.91 (PC08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/SP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)
/IO/PC09: H1.5, U1.90 (PC09/GPTMR0.CAPT1/UART2.RXD/I2C0.SDA/SP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)
/IO/PC10: H1.6, U1.89 (PC10/GPTMR0.COMP2/UART2.DE/UART2.RTS/SP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)
/IO/PC11: H1.7, U1.88 (PC11/UART2.CTS/SPI1.CS0/ESC0.GPI52/ESC0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)
/IO/PC12: H1.8, U1.87 (PC12/UART3.CTS/I2C1.SDA/SPI1.MISO/ESC0.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)
/IO/PC13: H1.9, U1.86 (PC13/GPTMR1.COMP3/UART3.DE/UART3.RTS/I2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)
/IO/PC14: H1.10, U1.85 (PC14/UART3.RXD/SPI1.DAT2/MCAN3.RXD/ESC0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)
/IO/PC15: H1.11, U1.84 (PC15/GPTMR0.COMP3/UART3.TXD/SPI1.DAT3/M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)
/IO/PC16: H1.12, U1.83 (PC16/GPTMR3.COMP0/UART4.TXD/ESC0.GPI47/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)
/IO/PD00: H1.13, U1.81 (PD00/MCAN0.TXD/ESC0.GPI31/ESC0.GPO32/PP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)
/IO/PD01: H1.14, U1.80 (PD01/MCAN0.RXD/ESC0.GPI30/ESC0.GPO33/PP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)
/IO/PD02: H1.15, U1.79 (PD02/I2C2.SCL/MCAN0.STBY/ESC0.GPI29/ESC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)
/IO/PD03: H1.16, U1.78 (PD03/I2C2.SDA/MCAN1.STBY/ESC0.GPI28/ESC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)
/IO/PD04: H1.17, U1.76 (PD04/MCAN1.RXD/ESC0.GPI27/ESC0.GPO36/PP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)
/IO/PD05: H1.18, U1.75 (PD05/MCAN1.TXD/ESC0.GPI26/ESC0.GPO37/PP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)
/IO/PD06: H1.19, U1.74 (PD06/I2C3.SDA/ESC0.GPI25/ESC0.GPO38/PPI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)
/IO/PD07: H1.20, U1.73 (PD07/I2C3.SCL/ESC0.GPI24/ESC0.GPO39/PPI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)
/IO/PF16: H1.27, U1.47 (PF16/SDM0.DAT0/ADC0.IN08/ADC1.IN08/ACMP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)
/IO/PF18: H1.29, U1.49 (PF18/SDM0.DAT1/USB0.PWR/ETH0.EVTO0/ESC0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)
/IO/PF19: H1.23, U1.42 (PF19/SDM0.CLK1/USB0.PWR/ADC0.IN13/ADC1.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)
/IO/PF20: H1.28, U1.48 (PF20/SDM0.DAT3/USB0.OC/ETH0.EVTO1/ESC0.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)
/IO/PF21: H1.25, U1.44 (PF21/SDM0.DAT2/USB0.ID/ETH0.EVTI0/ESC0.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)
/IO/PF22: H1.26, U1.46 (PF22/SDM0.CLK2/USB0.ID/ETH0.EVTI1/ESC0.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)
/IO/PF23: H1.24, U1.43 (PF23/SDM0.CLK3/USB0.OC/ADC0.IN15/ADC1.I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)
/IO/PF24: H1.22, U1.41 (PF24/SDM0.DAT0/ADC0.IN10/ADC1.IN10/ACMP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)
/IO/PF26: H1.30, U1.50 (PF26/SDM0.DAT1/ADC0.IN01/ADC1.IN01/ACMP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)
/IO/PF27: H1.21, U1.40 (PF27/SDM0.CLK1/ADC0.IN00/ADC1.IN00/ACMP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)
GND: C33.2, C34.2, H1.31, H1.32, H1.33, H1.34; also elsewhere on the board

Notes on the sheet:
IO 引出
空闲IO及部分ESC
电源输入 和滤波电容

Parts:
C1, C2: 12pF; C_0402_1005Metric
C3, C4, C5, C11, C12, C17, C18, C19, C21, C23, C24, C28, C29, C30, C31, C32: 100nF; C_0402_1005Metric
C6: 1uF; C_0402_1005Metric
C7, C20: 10uF; C_0603_1608Metric
C8, C9, C13, C14, C15, C16: 10uF; C_0402_1005Metric
C10: 10nF; C_0402_1005Metric
C22, C25, C26, C27: 22uF; C_0402_1005Metric
D1: SOD-323_L1.7-W1.3-LS2.5-BI; Manufacturer Part PESD3V3L1BA; LCSC Part Name PESD3V3L1BA
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1: 4.7uH; L_1008_2520Metric
R1, R2: 5.1K; R_0402_1005Metric
R3, R4: 10K; R_0402_1005Metric
R5: 3.16K; R_0402_1005Metric
R6: 1K; R_0402_1005Metric
SW1, SW2: SW-SMD_L3.9-W3.0-P4.45; Manufacturer Part TS-1088R-02026; LCSC Part Name 3.9*2.93*2mm 立贴 轻触开关
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm
U2: TPS74401_VQFN; VQFN-20_L5.0-W5.0-P0.65-TL-EP
Y1: 24Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/3V3: C8.2, C9.2, C11.2, C12.2, C14.2, C17.2, C20.1, C22.2, C23.1, C26.2, C29.2, D1.2 (A), R3.1, R5.1, SW2.1, U1.31 (DCDC_IN), U1.33 (VPMC), U1.37 (VANA), U1.39 (VREFH), U2.1 (OUT), U2.18 (OUT), U2.19 (OUT), U2.20 (OUT); also elsewhere on the board
/5V: C4.1, C6.1, C7.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.5 (IN), U2.6 (IN), U2.7 (IN), U2.8 (IN), U2.10 (BIAS), U2.11 (EN); also elsewhere on the board
/POWER/74401FB: R5.2, R6.1, U2.16 (FB)
/POWER/D+: J1.A6 (D+), J1.B6 (D+), U1.68 (USB0_DP)
/POWER/D-: J1.A7 (D-), J1.B7 (D-), U1.67 (USB0_DN)
/POWER/DCDC_LP: L1.1, U1.30 (DCDC_LP)
/POWER/DCDC_SNS: C21.2, C24.2, C25.2, C27.2, C28.2, C30.2, C31.2, C32.2, L1.2, U1.4 (VDD_SOC), U1.32 (DCDC_SNS), U1.52 (VDD_SOC), U1.71 (VDD_SOC), U1.77 (VDD_SOC), U1.98 (VDD_SOC)
/POWER/RESETN: C3.1, R3.2, SW1.1, U1.35 (RSTN)
/POWER/VDD_OTPCAP: C15.2, C18.2, U1.23 (VDD_OTPCAP)
/POWER/VDD_PMCCAP: C13.2, C16.2, C19.2, U1.34 (VDD_PMCCAP)
/POWER/WAKEUP: C5.1, R4.1, SW2.2, U1.36 (WKUP)
/POWER/XTALI: C1.2, U1.69 (XTALI), Y1.3
/POWER/XTALO: C2.2, U1.70 (XTALO), Y1.1
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, D1.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.2, R4.2, R6.2, SW1.2, U1.29 (DCDC_GND), U1.38 (VSSA/VREFL), U1.101 (PAD), U2.2 (NC), U2.3 (NC), U2.4 (NC), U2.12 (GND), U2.13 (NC), U2.14 (NC), U2.17 (NC), U2.21 (EP), Y1.2, Y1.4; also elsewhere on the board
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.1
unnamed: C10.1, U2.15 (SS)

Notes on the sheet:
TPS74401
电源及其基本外围电路
USB
复位和唤醒按键
